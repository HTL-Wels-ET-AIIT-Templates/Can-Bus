# Keil uVision project CanNetwork.uvprojx, settings and files
target STM32F429I-DISCO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO
  c include: inc; Libraries\CMSIS\inc; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\STM32F429iDisco_Board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./Libraries/Startup/: startup_stm32f429_439xx.s
  group CMSIS
    ./Libraries/CMSIS/src/: system_stm32f4xx.c
  group ST32F4xx_StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_usart.c
  group STM32F429I-DISCO
    ./Libraries/STM32F429iDisco_Board/src/: stm32f429i_discovery.c stm32f429i_discovery_ioe.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c fonts.c
  group User
    ./src/: DS18B20.c stm32_ub_can1.c stm32_ub_can2.c tempsensor.c can.c main.c
    ./inc/: DS18B20.h stm32_ub_can1.h stm32_ub_can2.h stm32f4xx_conf.h
software components: CMSIS:CORE 5.3.0
