# Keil uVision project CanNetwork.uvproj, settings and files
target STM32F429I-DISCO (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO
  c include: inc; Libraries\CMSIS\inc; Libraries\STM32F4xx_StdPeriph_Driver\inc; Libraries\STM32F429iDisco_Board\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group startup
    ./Libraries/Startup/: startup_stm32f429_439xx.s
  group CMSIS
    ./Libraries/CMSIS/src/: system_stm32f4xx.c
  group ST32F4xx_StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_fmc.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_ltdc.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_can.c stm32f4xx_usart.c
  group STM32F429I-DISCO
    ./Libraries/STM32F429iDisco_Board/src/: stm32f429i_discovery.c stm32f429i_discovery_ioe.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c fonts.c
  group User
    ./inc/: main.h DS18B20.h stm32_ub_can1.h stm32_ub_can2.h stm32f4xx_conf.h
    ./src/: DS18B20.c stm32_ub_can1.c stm32_ub_can2.c tempsensor.c can.c main.c
